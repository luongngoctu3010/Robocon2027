Commit message: Update Robocon 2027 Gazebo simulation

File: backup/tr_before_wheel_check.xacro (robot description, xacro)
@@ -19,5 +19,4 @@
 </visual>
 <collision>
-<origin xyz="0 0 0.165" rpy="0 0 0"/>
 <geometry>
 <box size="${chassis_x} ${chassis_y} ${chassis_z}"/>
